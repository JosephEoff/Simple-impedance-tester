options:
  parameters:
    author: Joseph Eoff
    generate_options: qt_gui
    id: Impedance_plotter
    output_language: python
    title: Impedance Plotter
  states: {}

blocks:
- name: block_size
  id: variable
  parameters:
    value: '8192'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: series_resistor
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0
    label: Series Resistor (ohms)
    min_len: '50'
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '100000'
    value: '20'
    widget: counter
  states: {}
- name: smoothing
  id: variable
  parameters:
    value: '0.03'
  states: {}
- name: units
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,1
    label: Units
    label0: ohms (impedance)
    label1: microfarads (capacitance)
    label2: microhenries (inductance)
    num_opts: '3'
    option1: microfarads (capacitance)
    option2: microhenries (inductance)
    type: string
    value: ohms (impedance)
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: sysdefault
    samp_rate: samp_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: sysdefault
    num_outputs: '2'
    ok_to_block: 'False'
    samp_rate: samp_rate
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    vlen: block_size
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters:
    vlen: block_size
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
    vlen: block_size
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: int(block_size/2)
    n: block_size
    offset: '0'
    type: float
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: series_resistor
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: block_size
    type: float
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: block_size
    type: float
  states: {}
- name: blocks_stream_to_vector_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: int(block_size/2)
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
    vlen: block_size
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: block_size
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import numpy 

      class ImpedanceConverter(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Calculates capacitance or inductance from impedances. """
          Impedance = "ohms (impedance)"
          Capacitance = "microfarads (capacitance)"
          Inductance = "microhenries (inductance)"
          def __init__(self, block_size=4096, samp_rate= 44100,  outputType=0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Impedance to inductance or capacitance converter',   # will show up in GRC
                  in_sig=[(np.float32, block_size)],
                  out_sig=[(np.float32, block_size)]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.block_size = block_size
              self.outputType = outputType
              self.samp_rate = samp_rate
              self.frequencies = numpy.arange(0,  self.block_size) * ((self.samp_rate/2)/self.block_size) * 2 * numpy.pi
              self.frequencies[0]=1

          def work(self, input_items, output_items):
              block = input_items[0].flatten(order='C')
              output_items[0][:] = self.calculateByOutputType(block)
              return len(output_items)

          def calculateByOutputType(self,  block):
              if self.outputType == self.Capacitance:
                  return self.calculateCapacitanceFromImpedance(block)
              if self.outputType == self.Inductance:
                  return self.calculateInductanceFromImpedance(block)
                  
              #No idea what we got, return the data unmodified
              return block
          
          def calculateInductanceFromImpedance(self,  impedances):
              impedances[0] = 0
              inductance = 1000000 * impedances/self.frequencies
              return inductance
              
          def calculateCapacitanceFromImpedance(self,  impedances):
              impedances[0] = 1
              #Need this because my sound card delivers a bunch of zeros if the input level goes too low.
              try:
                  capacitance = 1000000/(self.frequencies*impedances)
              except:
                  capacitance = impedances
              
              return capacitance
    block_size: int(block_size/2)
    outputType: units
    samp_rate: samp_rate
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: block_size
    forward: 'True'
    shift: 'True'
    type: float
    window: window.blackmanharris(block_size)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: block_size
    forward: 'True'
    shift: 'True'
    type: float
    window: window.blackmanharris(block_size)
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    color1: '"black"'
    grid: 'True'
    gui_hint: 1,0,4,5
    name: ''
    update_time: '0.01'
    vlen: int(block_size/2)
    x_axis_label: '"Frequency (Hz)"'
    x_start: '0'
    x_step: (samp_rate/2)/(block_size/2)
    x_units: '"Hz"'
    y_axis_label: ''
    y_units: units
    ymax: series_resistor*2
    ymin: '0'
  states: {}
- name: walkingaverage
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport scipy.signal\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Calculate a walking average of blocks of data.\"\"\"\n    \n    def __init__(self, block_size=4096, averaging=1.0, medianrank=51):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Walking average',   # will show up in GRC\n            in_sig=[(np.float32, block_size)], \n            out_sig=[(np.float32, block_size)]\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.averaging = averaging\n        self.block_size = block_size\n        self.lastblock = np.zeros(shape=(self.block_size))\n        self.medianrank = medianrank\n\n    def work(self, input_items, output_items):\n        newblock = scipy.signal.medfilt(input_items[0].flatten(order='C'),self.medianrank)\n        self.lastblock = (newblock - self.lastblock ) * self.averaging + self.lastblock\n        output_items[0][:] = self.lastblock\n        return len(output_items)\n\n"
    averaging: smoothing
    block_size: int(block_size/2)
    medianrank: '101'
  states: {}

connections:
- [analog_noise_source_x_0, '0', audio_sink_0, '0']
- [audio_source_0, '0', blocks_stream_to_vector_0, '0']
- [audio_source_0, '1', blocks_stream_to_vector_0_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_sub_xx_0, '0']
- [blocks_complex_to_mag_0_0, '0', blocks_divide_xx_0, '0']
- [blocks_complex_to_mag_0_0, '0', blocks_sub_xx_0, '1']
- [blocks_divide_xx_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_keep_m_in_n_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_stream_to_vector_0_0_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [blocks_stream_to_vector_0_0_0, '0', walkingaverage, '0']
- [blocks_sub_xx_0, '0', blocks_divide_xx_0, '1']
- [blocks_vector_to_stream_0, '0', blocks_keep_m_in_n_0, '0']
- [epy_block_0, '0', qtgui_vector_sink_f_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_0, '0']
- [fft_vxx_0_0, '0', blocks_complex_to_mag_0_0, '0']
- [walkingaverage, '0', epy_block_0, '0']

metadata:
  file_format: 1
